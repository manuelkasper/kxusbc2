# Repository manuelkasper/kxusbc2

File README.md:

# KXUSBC2 – Internal USB-C charger for the Elecraft KX2

The KXUSBC2 is an unofficial internal option for the Elecraft KX2 that adds a bidirectional USB-C port for charging the battery and powering external devices.

## Features

* Charge the internal battery or power an external device over USB-C at up to 30 W.
* Charge from USB-C or the KX2's DC jack, with support for USB PD 3.0, QC and BC1.2.
* Charging is suspended by default while the KX2 is on to avoid QRM.
* Includes an RTC, RGB status LED, configuration button and battery voltage monitoring.
* Supports optional battery temperature monitoring.

## Documentation

Visit the [KXUSBC2 documentation](https://manuelkasper.github.io/kxusbc2/docs/) for the [installation guide](https://manuelkasper.github.io/kxusbc2/docs/installation/), [user guide](https://manuelkasper.github.io/kxusbc2/docs/user_guide/) and [technical notes](https://manuelkasper.github.io/kxusbc2/docs/technical_notes/).

* [Where to buy](https://manuelkasper.github.io/kxusbc2/docs/#where-to-buy)
* [Web-based firmware programmer](https://manuelkasper.github.io/kxusbc2/programmer/)
* [License](https://manuelkasper.github.io/kxusbc2/docs/licence/) and [disclaimer](https://manuelkasper.github.io/kxusbc2/docs/disclaimer/)

The KXUSBC2 is not affiliated with or endorsed by Elecraft. Use it at your own risk.

## KiCad design hardware/pcb/kxusbc2.kicad_pcb

File hardware/README.md:

# Hardware notes

See the [hardware documentation](https://manuelkasper.github.io/kxusbc2/docs/technical_notes/hardware/) for the schematic, PCB and side panel specifications, manufacturing details, and measurements.

Parts:
H1: MountingHole_Pad; Wuerth_9774030151_HS; LCSC C5373032
H2: MountingHole_Pad; Wuerth_9774030151_HS
J1, J3, J4: Conn_01x03; TE_1-2307727-3; LCSC C3322456
J7, J8: Conn_01x01; SolderWire-0.5sqmm_1x01_D0.9mm_OD2.3mm
TP4, TP5, TP6, TP7: TestPoint; TestPoint_Pad_D1.0mm

Connections:
/BAT: J8.1; also elsewhere on the board
/Battery monitor/12VSW: J4.2; also elsewhere on the board
/Battery monitor/BTMON: J1.2; also elsewhere on the board
/Charger/SCL: TP4.1; also elsewhere on the board
/Charger/SDA: TP5.1; also elsewhere on the board
/Charger/~BQ_INT: TP7.1; also elsewhere on the board
/USB-C/~FUSB_INT: TP6.1; also elsewhere on the board
/VDC: J7.1; also elsewhere on the board
/uC/MISO: J3.1; also elsewhere on the board
/uC/MOSI: J4.3; also elsewhere on the board
/uC/RTC_CS: J1.3; also elsewhere on the board
/uC/SCK: J3.3; also elsewhere on the board
GND: H1.1, H2.1, J3.2; also elsewhere on the board

Notes on the sheet:
KX2 interface

Parts:
C1, C2, C5, C6, C7, C17, C18, C19, C20, C21, C25, C26: 10u; C_0805_2012Metric; LCSC C440198
C3: 47n; C_0603_1608Metric; LCSC C1622
C4: 47n; C_0603_1608Metric
C8, C9, C22, C23, C24: 0.1u; C_0402_1005Metric; LCSC C307331
C10: 4.7u; C_0603_1608Metric; LCSC C19666
C12: 1n; C_0402_1005Metric; LCSC C1588
C13, C14: 1n; C_0402_1005Metric; LCSC C1523
C27, C28, C36, C37: 1u; C_0402_1005Metric; LCSC C385032
D2, D3: 12V; D_SOD-523; LCSC C2993013
D10: 5.6V; D_SOD-523; LCSC C19077464
L1: APH0630T1R0M; L_APV_APH0630; PARTREV 20210423; LCSC C5349700
Q1, Q2, Q3, Q4: CSD17581Q3A; VSON-8_3.3x3.3mm_TI_CSD; LCSC C2861705
Q5: CSD25402Q3A; VSON-8_3.3x3.3mm_TI_CSD; LCSC C111356
R1: 10.5k; R_0402_1005Metric; LCSC C25850
R2: 5.24k; R_0402_1005Metric; LCSC C25907
R3: 30.31k; R_0402_1005Metric; LCSC C29402
R4, R13: 2; R_0402_1005Metric; LCSC C270630
R8: 100; R_0402_1005Metric; LCSC C25076
R9, R10: 330; R_0402_1005Metric; LCSC C25104
R11: 10k; R_0402_1005Metric; LCSC C25744
R12: 100k; R_0402_1005Metric
TH1: 10k
TP1, TP3: GND; TestPoint_Pad_2.5x2.5mm
TP2: T; TestPoint_Pad_2.5x2.5mm
U1: BQ25792RQMR; QFN40P400X400X100-29N; PARTREV 11/2019; LCSC C2862876

Connections:
/BAT: C1.1, C2.1, R8.2, U1.22 (BAT), U1.23 (BAT); also elsewhere on the board
/Charger/D+: U1.6 (D+); also elsewhere on the board
/Charger/D-: U1.7 (D-); also elsewhere on the board
/Charger/PMID: C5.1, C6.1, C7.1, C8.1, U1.29 (PMID)
/Charger/REGN: C10.1, R2.1, U1.5 (REGN), U1.17 (ILIM_HIZ)
/Charger/SCL: U1.14 (SCL); also elsewhere on the board
/Charger/SDA: U1.15 (SDA); also elsewhere on the board
/Charger/SW1: C3.1, L1.2, U1.28 (SW1)
/Charger/SW2: C4.2, L1.1, U1.26 (SW2)
/Charger/SYS: C9.1, C17.1, C18.1, C19.1, C20.1, C21.1, U1.25 (SYS)
/Charger/VBUS: C23.1, Q1.5 (D), R4.1, U1.9 (VAC1); also elsewhere on the board
/Charger/VBUS_BQ: C24.1, C25.1, C26.1, Q2.5 (D), Q4.5 (D), U1.2 (VBUS), U1.3 (VBUS)
/Charger/VBUS_SRC: C13.1, D2.2 (A), Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S)
/Charger/VDC_SAFE: C22.1, D10.1 (K), Q3.5 (D), Q5.5 (S), R11.1, U1.8 (VAC2)
/Charger/VDC_SRC: C14.1, D3.2 (A), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S)
/Charger/~BQ_CE: U1.13 (~CE); also elsewhere on the board
/Charger/~BQ_INT: U1.21 (~INT); also elsewhere on the board
/VDC: Q5.1 (D), Q5.2 (D), Q5.3 (D), R13.1; also elsewhere on the board
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C36.2, C37.2, R1.1, R3.2, R11.2, R12.2, TH1.2, TP1.1, TP3.1, U1.27 (GND); also elsewhere on the board
unnamed: C27.1, C36.1, R4.2
unnamed: C28.1, C37.1, R13.2
unnamed: C13.2, D2.1 (K), Q1.4 (G), Q2.4 (G), R9.2
unnamed: C14.2, D3.1 (K), Q3.4 (G), Q4.4 (G), R10.2
unnamed: D10.2 (A), Q5.4 (G), R12.1
unnamed: R9.1, U1.11 (ACDRV1)
unnamed: R10.1, U1.10 (ACDRV2)
unnamed: R8.1, U1.18 (BATP)
unnamed: C3.2, U1.4 (BTST1)
unnamed: C4.1, U1.19 (BTST2)
unnamed: R1.2, U1.20 (PROG)
unnamed: C12.2, U1.24 (SDRV)
unnamed: R2.2, R3.1, TH1.1, TP2.1, U1.16 (TS)

Parts:
C11: 4.7u; C_0402_1005Metric; LCSC C23733
C29, C39: 0.1u; C_0402_1005Metric; LCSC C307331
C31, C35: 1u; C_0402_1005Metric; LCSC C52923
C32, C33: 22p; C_0402_1005Metric; LCSC C1555
D1: APFA3010LSEEZGKQBKC; LED_Kingbright_APFA3010_3x1.5mm_Horizontal; LCSC C5393554
D4: BAT43XV2; D_SOD-523; LCSC C463439
D5: BAS16TW; SOT-363_SC-70-6; LCSC C155382
J2: UPDI; PinHeader_1x03_P2.54mm_Vertical
J6: Serial; PinHeader_1x03_P2.54mm_Vertical
R6, R7: 4.7k; R_0402_1005Metric; LCSC C25900
R17, R18: 100k; R_0402_1005Metric; LCSC C25741
SW1: SW_Push; SW_SPST_TS-1088-xR020; LCSC C720477
U2: ATtiny3226-M; VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm; LCSC C3216895
U4: RT9058-33GV; SOT-23-3; Manufacturer_Part_Number RT9058-33GV; Mouser Part Number 835-RT9058-33GV
U5: LP5815DRLR; SOTFL50P160X60-8N; Manufacturer_Part_Number LP5815DRLR; LCSC C47262831
Y1: 32.768 kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm; LCSC C276423

Connections:
+3V3: C11.1, C29.1, C31.1, D1.2 (A), D4.1 (K), J2.2, R6.1, R7.1, U2.4 (VCC), U4.2 (VOUT), U5.4 (VCC); also elsewhere on the board
/BAT: D5.3 (A); also elsewhere on the board
/Battery monitor/12VSW: R17.1; also elsewhere on the board
/Charger/SCL: R6.2, U2.14 (PB0), U5.1 (SCL); also elsewhere on the board
/Charger/SDA: R7.2, U2.13 (PB1), U5.2 (SDA); also elsewhere on the board
/Charger/VBUS: D5.2 (A); also elsewhere on the board
/Charger/~BQ_CE: U2.8 (PA7); also elsewhere on the board
/Charger/~BQ_INT: U2.7 (PA6); also elsewhere on the board
/USB-C/~FUSB_INT: U2.6 (PA5); also elsewhere on the board
/VDC: D5.1 (A); also elsewhere on the board
/uC/MISO: U2.16 (PC1); also elsewhere on the board
/uC/MOSI: U2.17 (PC2); also elsewhere on the board
/uC/RTC_CS: U2.18 (PC3); also elsewhere on the board
/uC/RXD: J6.1, U2.1 (PA2)
/uC/SCK: U2.15 (PC0); also elsewhere on the board
/uC/TXD: J6.2, U2.20 (PA1)
GND: C11.2, C29.2, C31.2, C32.1, C33.1, C35.2, C39.2, J2.3, J6.3, R18.2, SW1.2, U2.3 (GND), U2.21 (GND), U4.3 (GND), U5.3 (GND), U5.5 (STAT); also elsewhere on the board
unnamed: D1.4 (B), U5.8 (OUT0)
unnamed: D1.3 (G), U5.7 (OUT1)
unnamed: D1.1 (R), U5.6 (OUT2)
unnamed: C39.1, D4.2 (A), R17.2, R18.1, U2.2 (PA3)
unnamed: C35.1, D5.4 (K), D5.5 (K), D5.6 (K), U4.1 (VCC)
unnamed: J2.1, U2.19 (~RESET/PA0)
unnamed: SW1.1, U2.5 (PA4)
unnamed: C33.2, U2.12 (PB2), Y1.2
unnamed: C32.2, U2.11 (PB3), Y1.1

Notes on the sheet:
I2C addresses: 0x22: FUSB302B 0x2D: LP5815 0x6B: BQ25792

Parts:
C15, C30: 0.1u; C_0402_1005Metric; LCSC C307331
R5: 2.2M; R_0402_1005Metric; LCSC C138015
R14: 680k; R_0402_1005Metric; LCSC C4131
R15: 1k; R_0402_1005Metric; LCSC C11702
R16: 4.7k; R_0402_1005Metric; LCSC C25900
U3: TLV9301xDCK; SOT-353_SC-70-5; LCSC C4366617

Connections:
/BAT: R5.1; also elsewhere on the board
/Battery monitor/12VSW: C30.1, U3.5 (V+); also elsewhere on the board
/Battery monitor/BTMON: R15.2; also elsewhere on the board
GND: C15.2, C30.2, R14.1, R16.1, U3.2 (V-); also elsewhere on the board
unnamed: C15.1, R5.2, R14.2, U3.1 (+)
unnamed: R15.1, R16.2, U3.3 (-), U3.4

Parts:
C16: 0.1u; C_0402_1005Metric; LCSC C307331
C34, C38: 220p; C_0402_1005Metric; LCSC C1530
D6, D7, D8, D9: DESD5V0U1BL-7B; DESD5V0U1BL7B; LCSC C1869323
J5: GT-USB-7055AB; CONN_GT-USB-7055A_GSW; LCSC C22383826
U7: FUSB302BMPX; WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm; LCSC C132291

Connections:
+3V3: C16.2, U7.3 (VDD), U7.4 (VDD); also elsewhere on the board
/Charger/D+: D8.2 (A2), J5.A6 (D+), J5.B6 (D+); also elsewhere on the board
/Charger/D-: D9.2 (A2), J5.A7 (D-), J5.B7 (D-); also elsewhere on the board
/Charger/SCL: U7.6 (SCL); also elsewhere on the board
/Charger/SDA: U7.7 (SDA); also elsewhere on the board
/Charger/VBUS: J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), U7.2 (VBUS); also elsewhere on the board
/USB-C/CC1: C34.1, D6.2 (A2), J5.A5 (CC1), U7.10 (CC1), U7.11 (CC1)
/USB-C/CC2: C38.1, D7.2 (A2), J5.B5 (CC2), U7.1 (CC2), U7.14 (CC2)
/USB-C/~FUSB_INT: U7.5 (INT_N); also elsewhere on the board
GND: C16.1, C34.2, C38.2, D6.1 (A1), D7.1 (A1), D8.1 (A1), D9.1 (A1), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), U7.8 (GND), U7.9 (GND), U7.15 (GND); also elsewhere on the board

Board: 4 copper layers, 69.0 x 19.0 mm, 98 parts (26 on the bottom side), 55 nets.

File hardware/pcb/jlcpcb/production_files/BOM-kxusbc2.csv:

Comment,Designator,Footprint,LCSC,Quantity
0.1u,"C15,C16,C22,C23,C24,C29,C30,C39,C8,C9",C_0402_1005Metric,C307331,10
10.5k,R1,R_0402_1005Metric,C25850,1
100,R8,R_0402_1005Metric,C25076,1
100k,"R12,R17,R18",R_0402_1005Metric,C25741,3
10k,R11,R_0402_1005Metric,C25744,1
10u,"C1,C17,C18,C19,C2,C20,C21,C25,C26,C5,C6,C7",C_0805_2012Metric,C440198,12
12V,"D2,D3",D_SOD-523,C2993013,2
1k,R15,R_0402_1005Metric,C11702,1
1n,"C12,C13,C14",C_0402_1005Metric,C1523,3
1u,"C27,C28,C31,C35,C36,C37",C_0402_1005Metric,C52923,6
2,"R13,R4",R_0402_1005Metric,C270630,2
2.2M,R5,R_0402_1005Metric,C138015,1
220p,"C34,C38",C_0402_1005Metric,C1530,2
22p,"C32,C33",C_0402_1005Metric,C1555,2
30.31k,R3,R_0402_1005Metric,C29402,1
32.768 kHz,Y1,Crystal_SMD_2012-2Pin_2.0x1.2mm,C276423,1
330,"R10,R9",R_0402_1005Metric,C25104,2
4.7k,"R16,R6,R7",R_0402_1005Metric,C25900,3
4.7u,C10,C_0603_1608Metric,C19666,1
4.7u,C11,C_0402_1005Metric,C23733,1
47n,"C3,C4",C_0603_1608Metric,C1622,2
5.24k,R2,R_0402_1005Metric,C25907,1
5.6V,D10,D_SOD-523,C19077464,1
680k,R14,R_0402_1005Metric,C4131,1
APFA3010LSEEZGKQBKC,D1,LED_Kingbright_APFA3010_3x1.5mm_Horizontal,C5393554,1
APH0630T1R0M,L1,L_APV_APH0630,C5349700,1
ATtiny3226-M,U2,VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm,C3216895,1
BAS16TW,D5,SOT-363_SC-70-6,C155382,1
BAT43XV2,D4,D_SOD-523,C463439,1
BQ25792RQMR,U1,QFN40P400X400X100-29N,C2862876,1
CSD17581Q3A,"Q1,Q2,Q3,Q4",VSON-8_3.3x3.3mm_TI_CSD,C2861705,4
CSD25402Q3A,Q5,VSON-8_3.3x3.3mm_TI_CSD,C111356,1
Conn_01x03,"J1,J3,J4",TE_1-2307727-3,C3322456,3
DESD5V0U1BL-7B,"D6,D7,D8,D9",DESD5V0U1BL7B,C1869323,4
FUSB302BMPX,U7,WQFN-14-1EP_2.5x2.5mm_P0.5mm_EP1.45x1.45mm,C132291,1
GT-USB-7055AB,J5,CONN_GT-USB-7055A_GSW,C22383826,1
LP5815DRLR,U5,SOTFL50P160X60-8N,C47262831,1
MountingHole_Pad,"H1,H2",Wuerth_9774030151_HS,C5373032,2
RT9058-33GV,U4,SOT-23-3,C147968,1
SW_Push,SW1,SW_SPST_TS-1088-xR020,C720477,1
TLV9301xDCK,U3,SOT-353_SC-70-5,C4366617,1

## Commit log (part)

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2025-12-01 Clarify README
2025-12-02 Fix redundancy, document required menu setting
2025-12-03 Add info about ground connection
2025-12-03 Implement DC jack reverse polarity protection using P-channel MOSFET (closes #6)
2025-12-03 Remove tooling holes; not needed anymore as we need edge rails anyway now that we have components to assemble on both sides
2025-12-04 Update READMEs
2025-12-04 Update silkscreen positions
2025-12-04 Make debug/serial pads more staggered (closes #18)
2025-12-04 Clean up silkscreen label positions
2025-12-04 Fix RGB LED pin order
2025-12-04 Default to release build
2025-12-06 Implement hardware-assisted LED blinking
2025-12-07 Use nicer atomic primitives
2025-12-08 Make LED show charging phase (CC, CV, finished) (closes #5)
2025-12-08 Make sure we tickle watchdog even when not sleeping
2025-12-08 Reduce standby current by shutting down LED driver when not needed, and using TOG_SAVE_PWR (closes #9)
2025-12-08 Shave ~3.5 KB off the compiled code size using compiler options (and re-enable some debug now that we have more space)
2025-12-08 Improve LED handling, tone down reaction to faults
2025-12-08 Start with LED driver shut down
2025-12-09 Remove unnecessary line
2025-12-10 Revert accidental default charging voltage change. Add 100 mV headroom.
2025-12-10 Stop OTG if battery is low (closes #7)
2025-12-11 Increase via sizes where there is enough space
2025-12-13 Prevent optimizing away .eeprom section
2025-12-15 Fix case-sensitive include for Linux
2025-12-16 Swap LED green/blue for hardware rev2
2025-12-16 Add RTC calibration mode
2025-12-16 RTC calibration docs
2025-12-16 Update photos with rev2 hardware
2025-12-16 Add list of kit components
2025-12-18 Make RTC operation independent of calibration mode
2025-12-19 Add side panel version with handles
2025-12-19 Add drawing with dimensions for cutouts (for users who want to drill the original side panel)
2025-12-19 Fix overlap
2025-12-22 Initial import of web-based firmware programmer/configurator
2025-12-23 Implement config menu (closes #4)
2025-12-23 Update USER_GUIDE.md
    After upgrading the KX2 firmware from 2.69 to 3.02, the battery voltage indicator can be found under “BT”.
    This information was also posted on Elecraft KX groups.io.
    https://elecraft-kx.groups.io/g/main/topic/100601109#msg76332
2025-12-24 Add test points for I2C and interrupt lines
2025-12-25 Add photo of connected wires
2026-01-05 Reduce PCB height by 0.2 mm to improve fit (screws), and make U-shaped cutout for RF PCB screw 0.3 mm deeper (#45)
2026-01-05 Switch back to right-angle LED without light pipe (closes #41)
2026-01-05 Adjust height on top row of receptacle pads as well
2026-01-05 Add JLCPCB project DB (for rotation corrections), exclude test points from BOM
2026-01-05 Move inductor slightly away from bottom edge
2026-01-05 Document JLCPCB order settings
2026-01-05 Improve ground vias for SYS/PMID
2026-01-05 Move some parts further away from bottom edge
2026-01-07 "Breathing" => "Pulsing"
2026-01-10 Update legend, DNP
2026-01-10 SYS vias
2026-01-11 Add production files for rev3
2026-01-11 Add link to JLCPCB production files in README
2026-01-11 Remove parts that are not needed anymore
2026-01-11 Fix link
2026-01-14 Rotate J1/3/4 by 180 degrees as required by JLCPCB
2026-01-27 Erase flash before programming
2026-01-29 Update user guide and readme
2026-01-29 Make installation guide more concise
2026-01-30 Add fuses programming section
2026-02-03 Minor layout changes and cleanup
2026-02-03 Add info about thermistor
2026-02-03 Add photos off standoff soldering detail
2026-02-03 Update photo
2026-02-05 Add photo of applied Kapton tape
2026-02-05 Fix bogus undervoltage error after POR when ADC is not ready yet
2026-02-05 Mention direct soldering installation method
2026-02-05 Clarify harmonics of switching frequency
2026-02-06 Update photos for rev3
2026-02-06 Add Open Source Hardware logo
2026-02-10 Add "Where to buy" section
2026-02-10 Fix typo
2026-02-11 Add photo of replacement side panel with coating stripped
2026-02-12 Decrease default charging current limit to 2 A to be a bit friendlier to non high-capacity batteries (matches output current of KXBC2 external charger)
2026-02-12 Increase track widths of C3/C4. Fix JLC rotation of J1/J3/J4.
2026-02-16 Replace with photo of nicer Dremel job
2026-02-19 Clarify that heat shrink tubing is optional on white wire only
2026-02-19 Improve wording
2026-02-19 Clarify that battery should be removed during installation
2026-02-25 Clarify auto-suspend feature etc.
2026-03-02 Document TOG_SAVE_PWR patch
2026-03-02 Add LED diffuser and commentary
2026-03-03 Improve installation instructions
2026-03-03 Replace photo of stripped side panel with nicer, lasered version
2026-03-11 Add hysteresis to LED pulsing speed to avoid rapid toggling near thresholds (flickering green LED)
2026-03-11 Fix signedness warning
2026-03-11 Increase hysteresis
2026-03-16 Add a note that the battery must be connected
2026-03-18 Increase crystal load capacitors to 22p for more precise frequency pre-calibration
2026-04-20 Add new QRM measurements from fancy spectrum analyzer
2026-04-21 Add headroom to IOTG current limit to avoid VOTG drop if load draws slightly more current than advertised (measurement inaccuracies etc.) - fixes #52
2026-04-27 Add a photo to explain how to install the board without breaking the diffuser/LED
2026-05-04 Restructure user guide (separate part for hardware assembly as most users purchase a ready-made kit)
2026-05-04 Add divider
2026-05-04 Offset LED 1 mm from edge for better mechanical protection
2026-05-31 Clarify default settings in config menu documentation
    Added default setting indicators for config menu items.
2026-06-19 Remove schematic PDF and link to kicanvas.org instead

Notices in the files:
hardware/pcb/kxusbc2.kicad_pcb:
CC BY-SA 4.0
© 2025 HB9DQM
© HB9DQM
